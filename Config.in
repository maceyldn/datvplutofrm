## Config.in
```kconfig
#source "$BR2_EXTERNAL_PLUTOSDR_PATH/package/ffmpeg/Config.in"
source "$BR2_EXTERNAL_PLUTOSDR_PATH/package/libsrt/Config.in"
```
